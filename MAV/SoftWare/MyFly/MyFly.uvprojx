# Keil uVision project MyFly.uvprojx, settings and files
target MyFly (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyFly
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,
  c include: .\SRC\appllication;.\SRC\drivers;.\SRC\function;.\SRC\general;.\SRC\sensors_driver;.\Libraries\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./SRC/appllication/: BSP_Init.c main.c My_DT.c My_FlyCtrl.c My_Parameter.c My_Scheduler.c stm32f10x_it.c My_OF.c My_RC.c
  group General
    ./SRC/general/: My_FcData.c My_Filter.c My_Imu.c My_Math.c My_MotionCal.c My_Navigate.c My_Pid.c
  group Function
    ./SRC/function/: My_AltCtrl.c My_AttCtrl.c My_FlightCtrl.c My_FlightDataCal.c My_LocCtrl.c My_MagProcess.c My_MotorCtrl.c My_Power.c
  group Sensor_Driver
    ./SRC/sensors_driver/: Drv_ak8975.c Drv_icm20602.c Drv_led.c Drv_pwm_out.c Drv_spl06.c Drv_UP_Flow.c Drv_w25qxx.c Drv_nrf.c
  group Drivers
    ./SRC/drivers/: Drv_adc.c Drv_spi.c Drv_time.c Drv_usart.c
  group Firmware
    ./Libraries/src/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c startup_stm32f10x_md.s
